# Repository jacorg/DCI_CESE-7Co2018

## KiCad design FPGA_Lattice_Replica_Icezum/FPGA_Lattice_Replica_Icezum.kicad_pcb

Parts:
FID1, FID2, FID3: FIDUCIAL; Fiducial
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380

Notes on the sheet:
Power Supply
Peripherical
USB Communication
FPGA Lattice iCE40HX1K
Socket and Headers
Replica ICEZUM Alhambra Jacobo Salvador
Nota: La ICEZUM Alhambra esta basada en la FPGA iCE40HX1K de Lattice la cual fue abierto por el proyecto IceStorm de Clifford Wolf.
Mounting Hole
IceZUM Alhambra: an Arduino-like Open FPGAboard https://github.com/FPGAwars/icezum.git
Fiduciales
Nota gral 1: Se adpta trabajar con huellas 0805 o superior para mejor capacidad de trabajo de la placa. La original posee 0402.

Parts:
C59, C64, C65: 4.7 uF; C_0603
C60, C61: 10 nF; C_0603
C62, C66, C70: 100 nF; C_0603
C63, C68: 100 nF; C_0402
C67: 10 uF; C_1206
C69: 22 uF; C_1206
C71: 620 nF; C_0603
D2: BZX384C5V1-E3; LED_0603
D4: NSR0530HT1G; LED_0603
D10: SMAJ17CA; DO-214AC
D11: BAT54C-G3-08; SOT-23
D12: WHITE; LED_0603
J18: Power_Jack; JACK_2.1
L4: Ferrite_Bead; L_0603
L5: 2.2 uH 4,7A; L_4040
Q1, Q2: DMP3017; DFN-2523-6
Q3: DMP2035U-7; SOT-23
Q4: Mosfet_P_DFN-6; DFN-2523-6
Q5: PMBT3906; SOT-23
R24, R25, R27, R28, R30, R33, R34, R37, R38: 10K±5% 0.063 W; R_0402
R26, R29, R35, R36: 100K±5% 0.063 W; R_0402
R39: 1K±5% 0.063 W; R_0402
SW3: SPDT_Switch; slide-sw-spdt-right-angle
SW4: Switch; SW_vert_tht_7.5x6x6.5
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint_Small; Via_Test_point
U10: AP7361; DFN-3030-8
U11: TLV711; WSON-6
U12: TPS62133RGTR; QFN16
U13: APX810; SOT-23

Connections:
+1V2: C64.1, TP3.1, U11.6 (OUT1); also elsewhere on the board
+3V3_AUX: C65.1, TP4.1, U11.5 (OUT2); also elsewhere on the board
+5V: C68.1, C69.1, L5.2, Q3.3 (D), Q4.1 (S), Q4.2 (S), R30.1, R34.1, R36.1, TP1.1, U10.5 (EN), U10.8 (IN), U11.1 (EN1), U11.2 (IN), U11.3 (EN2), U12.7 (FSW), U12.14 (VOS), U13.3 (VCC); also elsewhere on the board
+5V_P: C63.1, Q4.4 (D), Q4.5 (D), Q4.6 (D), TP5.1; also elsewhere on the board
/Power Supply/5V_P_CTL: D11.1 (A1), R37.2, U13.1 (GND)
FPGA_RESET: D4.2 (A); also elsewhere on the board
GND: C59.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, D2.2 (A), D10.A, D12.K, J18.2, R25.2, R29.2, R39.2, SW3.3, SW4.1, U10.4 (GND), U10.9 (TP), U11.4 (GND), U12.5 (FB), U12.6 (AGND), U12.8 (DEF), U12.15 (PGND), U12.16 (PGND), U12.17 (TP); also elsewhere on the board
unnamed: C60.2, R24.1
unnamed: C61.1, Q1.3 (G), R25.1
unnamed: C61.2, C62.2, Q1.1 (S), Q1.2 (S), Q2.1 (S), Q2.2 (S), R26.1
unnamed: C62.1, Q2.3 (G), R24.2, R27.1
unnamed: C63.2, R35.1
unnamed: C66.1, L4.1
unnamed: C67.1, C70.1, L4.2, U12.10 (AVIN), U12.11 (PVIN), U12.12 (PVIN), U12.13 (EN)
unnamed: C71.1, U12.9 (SS/TR)
unnamed: D2.1 (K), Q3.1 (G), R28.1, R29.1
unnamed: D11.2 (A2), R26.2, R27.2
unnamed: D11.3 (K), SW3.2
unnamed: D12.A, R34.2
unnamed: L5.1, U12.1 (SW), U12.2 (SW), U12.3 (SW)
unnamed: Q4.3 (G), R33.1, R35.2
unnamed: Q5.3, R28.2
unnamed: R33.2, R36.2, R37.1, U13.2 (RESET)
Power: C60.1, Q2.4 (D), Q2.5 (D), Q2.6 (D), Q5.2, TP6.1; also elsewhere on the board
SYS_RESET: D4.1 (K), R30.2, SW4.2; also elsewhere on the board
VIN: D10.K, J18.1, Q1.4 (D), Q1.5 (D), Q1.6 (D); also elsewhere on the board

Notes on the sheet:
POWER SWITCH
OFF
RESET
General power flags
Esquemático de la fuente.
Debajo de cada IC se encuentra la hoja de datos
Led de encendido

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C12, C13, C14, C15, C16: 100 nF; C_0402
C11: 100 nF; C_0603
D1: NSR0530HT1G; SOD-323
FID1, FID2, FID3: FIDUCIAL; Fiducial
LD10: Yellow; LED_0603
R1, R2, R3, R4, R5, R6, R7, R8: 10K±5% 0.063W; R_0402
R9: 100K±5% 0.063W; R_0402
R46: 2K2±5% 0.063W; R_0402
U1: iCE40HX1K-TQ144; TQFP-144_IPC-MD
U2: N25Q032A; DFN-8-6x5mm

Connections:
+1V2: C13.1, C14.1, C15.1, C16.1, R9.1, U1.27 (VCC), U1.51 (VCC), U1.92 (VCC), U1.111 (VCC); also elsewhere on the board
FPGA_037_IO_PIN: U1.37 (IOB_24); also elsewhere on the board
FPGA_038_IO_PIN: U1.38 (IOB_25); also elsewhere on the board
FPGA_039_IO_PIN: U1.39 (IOB_26); also elsewhere on the board
FPGA_041_IO_PIN: U1.41 (IOB_27); also elsewhere on the board
FPGA_042_IO_PIN: U1.42 (IOB_28); also elsewhere on the board
FPGA_043_IO_PIN: U1.43 (IOB_29); also elsewhere on the board
FPGA_049_GBIN5: U1.49 (IOB_35_GBIN5); also elsewhere on the board
FPGA_050_GBIN4: U1.50 (IOB_36_GBIN4); also elsewhere on the board
FPGA_078_IO_PIN: U1.78 (IOR_52); also elsewhere on the board
FPGA_079_IO_PIN: U1.79 (IOR_53); also elsewhere on the board
FPGA_080_IO_PIN: U1.80 (IOR_54); also elsewhere on the board
FPGA_081_IO_PIN: U1.81 (IOR_55); also elsewhere on the board
FPGA_087_IO_PIN: U1.87 (IOR_56); also elsewhere on the board
FPGA_088_IO_PIN: U1.88 (IOR_57); also elsewhere on the board
FPGA_RESET: R2.1, R3.1, U1.66 (CRESET_B); also elsewhere on the board
FT_CTS: U1.4 (IOL_2B); also elsewhere on the board
FT_DCD: U1.1 (IOL_1A); also elsewhere on the board
FT_DSR: U1.2 (IOL_1B); also elsewhere on the board
FT_DTR: U1.3 (IOL_2A); also elsewhere on the board
FT_RTS: U1.7 (IOL_3A); also elsewhere on the board
FT_RX: U1.8 (IOL_3B); also elsewhere on the board
FT_TX: U1.9 (IOL_4A); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C13.2, C14.2, C15.2, C16.2, R4.2, U1.5 (GND), U1.13 (GND), U1.14 (GND), U1.59 (GND), U1.69 (GND), U1.86 (GND), U1.103 (GND), U1.132 (GND), U1.140 (GND), U2.4 (GND); also elsewhere on the board
LED_0: U1.95 (IOR_62); also elsewhere on the board
LED_1: U1.96 (IOR_63); also elsewhere on the board
LED_2: U1.97 (IOR_64); also elsewhere on the board
LED_3: U1.98 (IOR_65); also elsewhere on the board
LED_4: U1.99 (IOR_66); also elsewhere on the board
LED_5: U1.101 (IOR_67); also elsewhere on the board
LED_6: U1.102 (IOR_68); also elsewhere on the board
LED_7: U1.104 (IOR_69); also elsewhere on the board
unnamed: C11.1, C12.1, R9.2, U1.36 (VCCPLL)
unnamed: C11.2, C12.2, U1.35 (GNDPLL)
unnamed: D1.1 (K), U1.109 (VPP_FAST)
unnamed: LD10.K, R46.2
unnamed: R4.1, U1.77 (NC)
unnamed: R7.2, U2.7 (HOLD)
unnamed: R8.2, U2.3 (WP)
Power: C5.1, C6.1, C7.1, C8.1, U1.6 (VCCIO_3), U1.30 (VCCIO_3), U1.89 (VCCIO_1), U1.100 (VCCIO_1); also elsewhere on the board
iCE_CDONE: R1.1, U1.65 (CDONE); also elsewhere on the board
iCE_CLK: U1.21 (IOL_7A_GBIN6); also elsewhere on the board
iCE_CREST: R2.2; also elsewhere on the board
iCE_MISO: U1.68 (IOB_45_SDI), U2.2 (SD0); also elsewhere on the board
iCE_MOSI: U1.67 (IOB_44_SDO), U2.5 (SDI); also elsewhere on the board
iCE_SCK: R5.2, U1.70 (IOB_46_SCK), U2.6 (SCK); also elsewhere on the board
iCE_SS_B: R6.2, R46.1, U1.71 (IOB_47_SS_B), U2.1 (CS); also elsewhere on the board

Notes on the sheet:
FPGA iCE40HX1K-TQ144 (Lattice)
Output Leds

Parts:
C17, C24, C31: 4.7 uF; C_0603
C18, C19, C20, C21, C23, C25, C26, C27, C28, C29, C30, C33: 100 nF; C_0402
C22, C32: 10 nF; C_0603
F1: 0,5 A; F_1812
F2: ESDUSB; SOT-563
J1: USB_Micro_Type_B; USB_Micro-B
L1: 10 uH 0,1 A; L_0805
L2, L3: BLM18SG121TN1D; L_0603
LD8: Green; LED_0603
LD9: Yellow; LED_0603
R10, R15, R47, R48: 2K2±5% 0.063W; R_0402
R11: 12K±1% 0.063W; R_0402
R12, R13, R14: 10K±5% 0.063W; R_0402
R16: 0R±5% 0.063W; R_0402
TP8: TestPoint_Small; Via_Test_point
U3: FT2232H; FTDI-QFN-64
U4: DSC1001; Xtal-3_2x2_5
U5: 93LC56C; MSOP-8_3x3mm_Pitch0.65mm

Connections:
+1V8_FT: C19.1, C20.1, C21.1, C31.1, TP8.1, U3.12 (VCORE), U3.37 (VCORE), U3.49 (VREGOUT), U3.64 (VCORE)
/USB_communication/FT_CLK: R13.2, U3.62 (EECLK), U5.2 (CLK)
/USB_communication/FT_CS: R12.2, U3.63 (EECS), U5.1 (CS)
/USB_communication/FT_DATA: R15.2, U3.61 (EEDATA), U5.3 (DI)
/USB_communication/USB_N: F2.3, F2.4, J1.2, U3.7 (DM)
/USB_communication/USB_P: F2.1, F2.6, J1.3, U3.8 (DP)
FT_CTS: U3.41 (BDBUS3); also elsewhere on the board
FT_DCD: U3.45 (BDBUS6); also elsewhere on the board
FT_DSR: U3.44 (BDBUS5); also elsewhere on the board
FT_DTR: U3.43 (BDBUS4); also elsewhere on the board
FT_RTS: U3.40 (BDBUS2); also elsewhere on the board
FT_RX: U3.39 (BDBUS1); also elsewhere on the board
FT_TX: U3.38 (BDBUS0); also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, F2.2, F2.5, J1.1, J1.4, J1.5, J1.S1 (SHLD1), J1.S2 (SHLD2), J1.S3 (SHLD3), J1.S4 (SHLD4), J1.S5 (SHLD5), J1.S6 (SHLD6), R11.1, U3.1 (GND), U3.5 (GND), U3.10 (AGND), U3.11 (GND), U3.13 (TEST), U3.15 (GND), U3.25 (GND), U3.35 (GND), U3.47 (GND), U3.51 (GND), U4.2 (GND), U5.5 (VSS); also elsewhere on the board
unnamed: C17.1, C18.1, L1.2, U3.9 (VPLL)
unnamed: C22.2, F1.2, L2.2
unnamed: C23.2, L2.1
unnamed: C24.1, C25.1, L3.2, U3.4 (VPHY)
unnamed: LD8.K, R47.2
unnamed: LD9.K, R48.2
unnamed: R10.2, U3.14 (~RESET~)
unnamed: R11.2, U3.6 (REF)
unnamed: R14.2, R15.1, U5.4 (DO)
unnamed: R16.1, U3.2 (OSCI), U4.3 (OUTPUT)
unnamed: R47.1, U3.54 (BCBUS3)
unnamed: R48.1, U3.55 (BCBUS4)
iCE_CDONE: U3.23 (ADBUS6); also elsewhere on the board
iCE_CLK: R16.2; also elsewhere on the board
iCE_CREST: U3.24 (ADBUS7); also elsewhere on the board
iCE_MISO: U3.18 (ADBUS2); also elsewhere on the board
iCE_MOSI: U3.17 (ADBUS1); also elsewhere on the board
iCE_SCK: U3.16 (ADBUS0); also elsewhere on the board
iCE_SS_B: U3.21 (ADBUS4); also elsewhere on the board

Schematic: Peripherical.sch

Parts:
C34, C35, C45, C46: 100 nF; C_0402
C41: 4.7 uF; C_0603
J15, J16, J17: 1x4_male_pin_Header_2.54mm; 1x04-pin-header-2.54mm
JP1: Jumper_3pin; 1x03-pin-header-2.54mm
LD0, LD1, LD2, LD3, LD4, LD5, LD6, LD7: Green; LED_0603
R17, R18, R40, R41, R42, R43, R44, R45: 2K2±5% 0.063W; R_0402
R19, R20, R21, R31, R32: 10K±5% 0.063W; R_0402
SW1: SW1; SW_SMD_60X3.8
SW2: Switch_4p; SW_SMD_60X3.8
U7: ADS7924; QFN16

Connections:
GND: C34.2, C35.2, C41.1, C45.2, C46.1, LD0.K, LD1.K, LD2.K, LD3.K, LD4.K, LD5.K, LD6.K, LD7.K, R31.2, R32.2; also elsewhere on the board
LED_0: R17.2; also elsewhere on the board
LED_1: R18.2; also elsewhere on the board
LED_2: R40.2; also elsewhere on the board
LED_3: R41.2; also elsewhere on the board
LED_4: R42.2; also elsewhere on the board
LED_5: R43.2; also elsewhere on the board
LED_6: R44.2; also elsewhere on the board
LED_7: R45.2; also elsewhere on the board
unnamed: C41.2, C46.2, R19.1
unnamed: LD0.A, R17.1
unnamed: LD1.A, R18.1
unnamed: LD2.A, R40.1
unnamed: LD3.A, R41.1
unnamed: LD4.A, R42.1
unnamed: LD5.A, R43.1
unnamed: LD6.A, R44.1
unnamed: LD7.A, R45.1

Notes on the sheet:
Polarized Output Leds
Switch buttons 1 and 2

Parts:
C47, C48: 100 nF; L_0805
J5: 1x8_male_pin_Header_2.54mm; 1x8_Socket_header_2.54mm
J11: 1x6_female_pin_Header_2.54mm; 1x6-Socket-header-2.54mm
J13, J14: 1x6_female_pin_Header_2.54mm; 1x6-pin-header-2.54mm
J19: 2x4_male_pin_Header_2.54mm; 2x04-pin-header-2.54mm
R22, R23: 4K7±5% 0.063W; F_0805
U8: TXB0108; VQFN20

Connections:
+3V3_AUX: J5.4; also elsewhere on the board
+5V: C48.1, J5.2, R22.1, R23.1, U8.19 (VCCB); also elsewhere on the board
+5V_P: J5.5, J13.1, J13.2, J13.3, J13.4, J13.5, J13.6; also elsewhere on the board
/socketsAndHeaders/DD0: J11.1, U8.12 (B8)
/socketsAndHeaders/DD1: J11.2, U8.13 (B7)
/socketsAndHeaders/DD2: J11.3, U8.14 (B6)
/socketsAndHeaders/DD3: J11.4, U8.15 (B5)
/socketsAndHeaders/DD4: J11.5, R23.2, U8.16 (B4)
/socketsAndHeaders/DD5: J11.6, R22.2, U8.17 (B3)
FPGA_037_IO_PIN: J19.1; also elsewhere on the board
FPGA_038_IO_PIN: J19.2; also elsewhere on the board
FPGA_039_IO_PIN: J19.3; also elsewhere on the board
FPGA_041_IO_PIN: J19.4; also elsewhere on the board
FPGA_042_IO_PIN: J19.5; also elsewhere on the board
FPGA_043_IO_PIN: J19.6; also elsewhere on the board
FPGA_049_GBIN5: J19.7; also elsewhere on the board
FPGA_050_GBIN4: J19.8; also elsewhere on the board
FPGA_078_IO_PIN: U8.9 (A8); also elsewhere on the board
FPGA_079_IO_PIN: U8.8 (A7); also elsewhere on the board
FPGA_080_IO_PIN: U8.7 (A6); also elsewhere on the board
FPGA_081_IO_PIN: U8.6 (A5); also elsewhere on the board
FPGA_087_IO_PIN: U8.4 (A3); also elsewhere on the board
FPGA_088_IO_PIN: U8.5 (A4); also elsewhere on the board
GND: C47.1, C48.2, J5.6, J5.7, J14.1, J14.2, J14.3, J14.4, J14.5, J14.6, U8.11 (GND), U8.21 (TP); also elsewhere on the board
SYS_RESET: J5.3; also elsewhere on the board
VIN: J5.8; also elsewhere on the board

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
Board: 4 copper layers, 87.5 x 63.0 mm, 160 parts (0 on the bottom side), 106 nets.

## Commit log

2019-05-01 Creación de repo DCI con Datasheet y resumen del proyecto de la CESE
2019-06-03 se agrega carpeta de proyecto con diseño jerarquico y se comenzo por el esquematico de la fuente de alimentación
2019-06-05 se genero esquematico del modulo FPGA y la conexion USB
2019-06-10 se completo esquema de perifericos y sockets. Se puso el mismo simbolo de referencia GND en el esquema de la fuente
2019-06-11 se ejecuto y se corrigio electrical rules check
2019-06-11 se comenzo asignacion de footprints
2019-06-11 se finalizo asignación de footprint de acuerdo al modelo original de la icezum alhambra
2019-06-11 se coloco hojas de datos de los componentes
2019-06-12 se realizo las correcciones sugeridas por el revisor
2019-06-17 se agregaron mas comentarios a las hojas estado del esquematico: finalizado
2019-06-19 se corrigieron errores de huellas y referencias que genereban errores cuando se hacia el diseño PCB
2019-06-28 se comenzo PCB terminado ordenamiento y borde de placa
2019-07-01 se mejoro esquematico de acuerdo a la revisión del docente. Se mejoro rotulo (se coloco link del repo, autor y autor de la versión original y la licencia) se mejoro el flujo izquiera derecha de los b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
2019-07-02 Posicionamiento y PCB finalizado al 90% realizado en 4 capas. Relleno ce Cu
2019-07-03 nota para fabricante, serigrafia y logo open source. PCB finalizado para presentar
2019-07-15 correcciones de serigrafia, componentes 3D, se corrigio relleno de cobre, simetria en agujero y cambio en la grilla para corte de placa, se corrigieron cuestion de ruteo y uniformidad en la vias. Se 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

Notices in the files:
FPGA_Lattice_Replica_Icezum/FPGA_Lattice_Replica_Icezum.kicad_pcb:
License: Creative commons Attribution ShareAlike
